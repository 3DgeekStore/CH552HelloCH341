# Keil uVision project CH341hello.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C59 SST
  cpu: IRAM(0-0xFF) XRAM(0-0xff) IROM(0-0xFFFF) CLOCK(33000000)
  output: CH341hello +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DEBUG.C USB_Serial.c CH554.H DEBUG.H USB_Serial.h CH554.INC
